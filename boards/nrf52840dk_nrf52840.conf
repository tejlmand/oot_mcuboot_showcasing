## boards/nrf52840dk_nrf52840.conf
```kconfig
# Ensure that the qspi driver is disabled by default
CONFIG_LOG_DEFAULT_LEVEL=1
CONFIG_NORDIC_QSPI_NOR=n
```
